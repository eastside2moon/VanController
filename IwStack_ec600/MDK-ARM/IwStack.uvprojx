# Keil uVision project IwStack.uvprojx, settings and files
target IwStack (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: IwStack +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;          ../Drivers/STM32F1xx_HAL_Driver/Inc;          ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;          ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;          ../Drivers/CMSIS/Include;          ../Middlewares/Third_Party/FreeRTOS/Source/include;          ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;          ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;          ..\..\+Component\ApsFunc;          ..\..\+Component\Common;          ..\..\+Component\Driver;          ..\..\+Component\Network;          ..\..\+Component\Peripheral;          ..\..\+Component\Protocol;          ..\..\+Component\Protocol\mqtt_mbed
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../Core/Src/: app_cat1_ali.c utils_hmac.c utils_md5.c utils_sha1.c
    ../Core/Inc/: prj_config.h net_communicate.h
  group Driver
    ../../+Component/Driver/: FONT.c FONT.h key.c key.h led.c led.h oled.c oled.h sht20.c sht20.h mpu6050.c mpu6050.h
  group Peripheral
    ../../+Component/Peripheral/: chip.c chip.h flash.c flash.h uart1_print.c uart1_print.h uart3_mod.c uart3_mod.h
  group Network
    ../../+Component/Network/: mod_api_ec600.c mod_api_ec600.h netdriver_ec600.c netdriver_ec600.h socket_buf.c socket_buf.h
  group MQTT
    ../../+Component/Protocol/mqtt_mbed/: MQTTPacket.c MQTTConnectClient.c MQTTSerializePublish.c MQTTDeserializePublish.c MQTTSubscribeClient.c
  group API
    ../../+Component/Protocol/: cJSON.c cJSON.h
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_3.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 4.3.0
